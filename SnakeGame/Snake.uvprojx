# Keil uVision project Snake.uvprojx, settings and files
target FRDM-KL05ZJ (6240000::V6.24::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Snake
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c lcd_i2c.h lcd_i2c.c adc_joy.h adc_joy.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS:CORE 6.1.1, Device:Startup 1.0.0
